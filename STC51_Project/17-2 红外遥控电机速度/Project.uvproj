# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h Int0.c Int0.h Timer0.c Timer0.h IR.c IR.h Motor.c Motor.h Timer1.c Timer1.h
