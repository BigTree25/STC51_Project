# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h I2C.c I2C.h
    ../6-1 矩阵键盘/: Delay.c Delay.h LCD1602.c LCD1602.h
    ../7-1 按键控制LED流水的模式/: Key.c Key.h
